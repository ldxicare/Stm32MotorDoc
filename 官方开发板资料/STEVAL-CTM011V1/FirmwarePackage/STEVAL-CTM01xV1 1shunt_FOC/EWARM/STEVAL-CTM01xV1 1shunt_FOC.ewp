# IAR project STEVAL-CTM01xV1 1shunt_FOC.ewp, settings and files
configuration STEVAL-CTM01xV1 1shunt_FOC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F031C6 ST STM32F031C6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 5
  ICCARM.CCDefines: ARM_MATH_CM0; USE_HAL_DRIVER; STM32F031x6
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../MCSDK_v5.4.4/MotorControl/MCSDK/MCLib/Any/Inc; ../MCSDK_v5.4.4/MotorControl/MCSDK/MCLib/F0xx/Inc; ../MCSDK_v5.4.4/MotorControl/MCSDK/UILibrary/Inc; ../MCSDK_v5.4.4/MotorControl/MCSDK/SystemDriveParams; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/DSP/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STEVAL-CTM01xV1 1shunt_FOC.hex
  ILINK.IlinkOutputFile: STEVAL-CTM01xV1 1shunt_FOC.out
  ILINK.IlinkIcfFile: stm32f031x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f031x6.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c motor_control_protocol.c mc_config.c mc_tasks.c regular_conversion_manager.c mc_math.c mc_interface.c stm32f0xx_mc_it.c mc_parameters.c ui_task.c user_interface.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.4/MotorControl/lib/: libmc-iar_M0.a
    ../MCSDK_v5.4.4/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c
    ../MCSDK_v5.4.4/MotorControl/MCSDK/MCLib/F0xx/Src/: r1_f0xx_pwm_curr_fdbk.c
    ../MCSDK_v5.4.4/MotorControl/MCSDK/UILibrary/Src/: ui_irq_handler.c
